# IAR project flexcan_nonblocking_m40.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8QM6_M4_0 NXP MIMX8QM6_M4_0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; FLEXCAN_WAIT_TIMEOUT=1000
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; CMSIS; MIMX8QM6; component/lists; component/uart; device; drivers; mekmimx8qm/driver_examples/flexcan/interrupt_transfer/cm4_core0; scfw_api; scfw_api/main; scfw_api/svc; scfw_api/svc/irq; scfw_api/svc/misc; scfw_api/svc/pad; scfw_api/svc/pm; scfw_api/svc/rm; scfw_api/svc/seco; scfw_api/svc/timer; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: m4_image.bin
  ILINK.IlinkOutputFile: flexcan_nonblocking_m40.out
  ILINK.IlinkIcfFile: MIMX8QM6/iar/MIMX8QM6xxxFF_cm4_core0_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; FLEXCAN_WAIT_TIMEOUT=1000
  AARM.ADefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QM6/iar/MIMX8QM6xxxFF_cm4_core0_flash.icf
configuration ddr_debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: as above
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QM6/iar/MIMX8QM6xxxFF_cm4_core0_ddr_ram.icf
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; FLEXCAN_WAIT_TIMEOUT=1000
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMX8QM6AVUFF_cm4_core0; MIMX8QM_CM4_CORE0; FLEXCAN_WAIT_TIMEOUT=1000
  ICCARM.CCOptLevel: 3
  AARM.ADefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8QM6/iar/MIMX8QM6xxxFF_cm4_core0_flash.icf
configuration ddr_release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  ILINK.IlinkIcfFile: MIMX8QM6/iar/MIMX8QM6xxxFF_cm4_core0_ddr_ram.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MIMX8QM6_cm4_core0.h MIMX8QM6_cm4_core0_features.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcan.c fsl_flexcan.h fsl_gpio.c fsl_gpio.h fsl_irqsteer.c fsl_irqsteer.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_rgpio.c fsl_rgpio.h
  group MIMX8QM6
    MIMX8QM6/: system_MIMX8QM6_cm4_core0.c system_MIMX8QM6_cm4_core0.h
  group MIMX8QM6/iar
    MIMX8QM6/iar/: MIMX8QM6xxxFF_cm4_core0_ddr_ram.icf MIMX8QM6xxxFF_cm4_core0_flash.icf MIMX8QM6xxxFF_cm4_core0_ram.icf startup_MIMX8QM6_cm4_core0.s
  group remoteproc
    remoteproc/: empty_rsc_table.c
  group scfw_api/main
    scfw_api/main/: imx8qm_pads.h ipc.h ipc_imx8qm.c rpc.h scfw.h types.h
  group scfw_api/svc/irq
    scfw_api/svc/irq/: irq_api.h irq_rpc.h irq_rpc_clnt.c
  group scfw_api/svc/misc
    scfw_api/svc/misc/: misc_api.h misc_rpc.h misc_rpc_clnt.c
  group scfw_api/svc/pad
    scfw_api/svc/pad/: pad_api.h pad_rpc.h pad_rpc_clnt.c
  group scfw_api/svc/pm
    scfw_api/svc/pm/: pm_api.h pm_rpc.h pm_rpc_clnt.c
  group scfw_api/svc/rm
    scfw_api/svc/rm/: rm_api.h rm_rpc.h rm_rpc_clnt.c
  group scfw_api/svc/seco
    scfw_api/svc/seco/: seco_api.h seco_rpc.h seco_rpc_clnt.c
  group scfw_api/svc/timer
    scfw_api/svc/timer/: timer_api.h timer_rpc.h timer_rpc_clnt.c
  group source
    source/: flexcan_interrupt_transfer.c
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
